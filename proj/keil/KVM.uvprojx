# Keil uVision project KVM.uvprojx, settings and files
target KVM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: KVM
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\..\src\App;..\..\src\Hal;..\..\src\Lib\inc;..\..\src\Sys;..\..\src\Hal\core
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Sys
    ../../src/Sys/: Sys.c
  group Lib
    ../../src/Lib/src/: misc.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_rcc.c
  group Hal
    ../../src/Hal/: Hal.c HalGPIO.c HalTimer.c HalUart.c HalWait.c
  group App
    ../../src/App/: Keyboard.c KVM.c main.c Protocol.c
  group core
    ../../src/Hal/core/: stm32f4xx_it.c system_stm32f4xx.c startup_stm32f40_41xxx.s
